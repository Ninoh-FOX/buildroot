## board/opendingux/package/libshake2/Config.in
```kconfig
config BR2_PACKAGE_LIBSHAKE2
	bool "libshake2"
	help
	  A simple, cross-platform haptic library.

	  https://github.com/zear/libShake
```
